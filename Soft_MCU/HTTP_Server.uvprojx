# Keil uVision project HTTP_Server.uvprojx, settings and files
target MCBSTM32F400 V1.1 (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4 oTime=1
  c define: NDEBUG  nDEBUG  _nDEBUG  __nDEBUG        INI_ASCIILINESZ=127  INI_DICTMINSZ=16        MINI_STM32F429   STM32F407xx    HSE_VALUE=25000000    USE_FULL_ASSERT    USE_HAL_DRIVER    __RTX    _RTE_
  c include: .\IniParser\src;.\Web;.\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./App/: main.c netiod.c net_user.c net_http_cgi.c cfg.c crc.c ProfiBUS_DP.c
  group IniParser
    ./IniParser/src/: iniparser.c dictionary.c
  group BSP
    ./BSP/: board.c stm32f4_iap_flash.c SVC_Table.s STM32F40xxx_41xxx_OPT.s STM32F4xx_OTP.s
    ./RTE/Compiler/: stdio_usart.c
  group WEB
    ./: HTTP_Server.c HTTP_Server_CGI.c HTTP_Server_Error.c
    ./Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Board Support:A/D Converter 2.0.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, File System:CORE 6.4.0, File System:Drive:NOR 6.4.0, Network:CORE 6.4.0, Network:Interface:ETH 6.4.0, Network:Service:FTP Server 6.4.0, Network:Service:Web Server 6.4.0, Network:Socket:BSD 6.4.0, Network:Socket:TCP 6.4.0, Network:Socket:UDP 6.4.0, CMSIS Driver:Ethernet MAC 2.01, CMSIS Driver:Ethernet PHY:DP83848C 6.00, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.00, CMSIS Driver:Ethernet PHY:ST802RT1 6.00, CMSIS Driver:Flash:S29GL064Nx2 1.00, CMSIS Driver:USART 2.01, Compiler:I/O:File 1.0.0, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Compiler:I/O:TTY 1.0.0, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:ADC 1.1.0, Device:STM32Cube HAL:CAN 1.1.0, Device:STM32Cube HAL:CRC 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DAC 1.1.0, Device:STM32Cube HAL:DCMI 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:ETH 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:HCD 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:I2S 1.1.0, Device:STM32Cube HAL:IRDA 1.1.0, Device:STM32Cube HAL:IWDG 1.1.0, Device:STM32Cube HAL:NAND 1.1.0, Device:STM32Cube HAL:NOR 1.1.0, Device:STM32Cube HAL:PC Card 1.1.0, Device:STM32Cube HAL:PCD 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:RNG 1.1.0, Device:STM32Cube HAL:RTC 1.1.0, Device:STM32Cube HAL:SD 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:SRAM 1.1.0, Device:STM32Cube HAL:Smartcard 1.1.0, Device:STM32Cube HAL:TIM 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:STM32Cube HAL:WWDG 1.1.0, Device:Startup 2.1.0
